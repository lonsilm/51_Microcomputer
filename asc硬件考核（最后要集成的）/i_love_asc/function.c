#include <REGX52.H>
#include "matrixled.h"

unsigned char code i_love_asc[] =//I SUPER LOVE ASC
{
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00, 
0x81,0xFF,0x81,0x00,0x00,0x32,0x49,0x26,
0x00,0x3C,0x02,0x02,0x3C,0x00,0x7F,0x48,
0x30,0x00,0x1C,0x2A,0x2A,0x18,0x00,0x3E,
0x10,0x20,0x10,0x00,0x00,0x38,0x44,0x42,
0x21,0x42,0x44,0x38,0x00,0x00,0x01,0x04,
0x18,0x48,0xFF,0x00,0x72,0x89,0x89,0x66,
0x00,0x7E,0x81,0x81,0x66,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00, 
};

void show_i_love_asc()
{
    unsigned char i=0;
    static unsigned char setoff=0,cnt=0;
    for(i=0;i<8;i++)
        {
            MatrixLED_ShowColumn(i,i_love_asc[i+setoff]);
        }
        cnt++;
        if(cnt==10)
        {
            cnt=0;
            setoff++;
        }

        if(setoff==72-8)
        {
            setoff=0;
        }
}