#include <REGX52.H>
#include "Delay.h"
#include "Mixtri Keyboard.h"
#include "matrixled.h"

// 合并数字图案为二维数组，便于索引和维护
unsigned char code digits[10][8] = {
    {0x00,0x00,0x7E,0x81,0x81,0x7E,0x00,0x00}, // 0
    {0x00,0x00,0x41,0xFF,0xFF,0x01,0x00,0x00}, // 1
    {0x00,0x41,0x83,0x85,0x89,0x71,0x00,0x00}, // 2
    {0x00,0x42,0x81,0x89,0x89,0x76,0x00,0x00}, // 3
    {0x00,0x18,0x78,0x08,0xFF,0x08,0x08,0x00}, // 4
    {0x00,0x08,0xF1,0x51,0x51,0x0E,0x00,0x00}, // 5
    {0x00,0x7E,0x91,0x91,0x91,0x4E,0x00,0x00}, // 6
    {0x00,0x80,0x80,0x81,0x8C,0xE0,0x00,0x00}, // 7
    {0x00,0x6E,0x91,0x91,0x91,0x6E,0x00,0x00}, // 8
    {0x00,0x72,0x89,0x89,0x89,0x7E,0x00,0x00}  // 9
};

unsigned char code A_zimo[8] = {0x00,0x01,0x04,0x18,0x48,0xFF,0x00,0x00};
unsigned char code S_zimo[8] = {0x00,0x66,0x91,0x89,0x89,0x66,0x00,0x00};
unsigned char code C_zimo[8] = {0x00,0x7E,0x81,0x81,0x81,0x81,0x66,0x00};

void control_matrix_led()
{
    unsigned char mixkey_num, i;
    mixkey_num = Mix_key_num();

    // 如果是数字 0..9，直接从 digits 表中取图案
    if(mixkey_num <= 9)
    {
        
        for(i = 0; i < 8; i++)
        {
            MatrixLED_ShowColumn(i, digits[mixkey_num][i]);
            Delayms(2);
        }
        
    }

    // 处理字母或特殊键
    switch(mixkey_num)
    {
        case 11:
            for(i = 0; i < 8; i++) { MatrixLED_ShowColumn(i, A_zimo[i]); Delayms(2); }
            break;
        case 12:
            for(i = 0; i < 8; i++) { MatrixLED_ShowColumn(i, S_zimo[i]); Delayms(2); }
            break;
        case 13:
            for(i = 0; i < 8; i++) { MatrixLED_ShowColumn(i, C_zimo[i]); Delayms(2); }
            break;
        default:
            // 未定义或无按键时，可选择清空或保持当前显示，此处不改变显示
            break;
    }
}