# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c function.c function.h Clean.c Clean.h Delay.c Delay.h Key.c Key.h SMG.c SMG.h Timer0.c Timer0.h MatrixLED.c MatrixLED.h Mixtri Keyboard.c Mixtri Keyboard.h LCD1602.c LCD1602.h xpt2046.c xpt2046.h UART.c UART.h
