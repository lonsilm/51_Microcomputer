# Keil uVision project projhect.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: projhect +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Clean.c Clean.h Delay.c Delay.h Key.c Key.h SMG.c SMG.h function.c function.h Timer0.c Timer0.h
