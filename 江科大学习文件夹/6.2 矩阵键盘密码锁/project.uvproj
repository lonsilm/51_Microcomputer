# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h Mixtri Keyboard.c Mixtri Keyboard.h LCD1602.h LCD1602.c
    ../EX 生日礼物/: Timer0.c Timer0.h
